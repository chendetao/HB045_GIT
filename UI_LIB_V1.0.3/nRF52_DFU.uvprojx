# Keil uVision project nRF52_DFU.uvprojx, settings and files
target nRF52_xxAA_S132 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: app +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: CONFIG_USING_ANCS=0 CONFIG_USING_WECHAT=0 CONFIG_USING_FPU=1 BLE_DFU_APP_SUPPORT BLE_STACK_SUPPORT_REQD S132 NRF52_PAN_24 NRF52_PAN_25 NRF52_PAN_26 NRF52_PAN_27 NRF52_PAN_28 NRF52_PAN_29 NRF52_PAN_30 NRF52_PAN_32 NRF52_PAN_33 NRF52_PAN_34 NRF52_PAN_35 NRF52_PAN_36 NRF52_PAN_37 NRF52_PAN_38 NRF52_PAN_39 NRF52_PAN_40 NRF52_PAN_41 NRF52_PAN_42 NRF52_PAN_43 NRF52_PAN_44 NRF52_PAN_46 NRF52_PAN_47 NRF52_PAN_48 NRF52_PAN_49 NRF52_PAN_58 NRF52_PAN_63 NRF52_PAN_64 NRF52_PAN_65 CONFIG_GPIO_AS_PINRESET  NRF52_PAN_1 NRF52_PAN_2 NRF52_PAN_3 NRF52_PAN_4 NRF52_PAN_7 NRF52_PAN_8 NRF52_PAN_9 NRF52_PAN_10 NRF52_PAN_11 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_16 NRF52_PAN_17 NRF52_PAN_20 NRF52_PAN_23 NRF_LOG_USES_UART=0 SWI_DISABLE0 SOFTDEVICE_PRESENT NRF52
  c include: .\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\common;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\hal;.\nRF5_SDK_11.0.0_89a8197\components\libraries\util;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\delay;.\nRF5_SDK_11.0.0_89a8197\components\softdevice\s132\headers;.\nRF5_SDK_11.0.0_89a8197\components\ble\ble_services\ble_dfu;.\nRF5_SDK_11.0.0_89a8197\components\ble\common;.\nRF5_SDK_11.0.0_89a8197\components\libraries\bootloader_dfu;.\nRF5_SDK_11.0.0_89a8197\components\ble\device_manager;.\nRF5_SDK_11.0.0_89a8197\components\ble\device_manager\config;.\nRF5_SDK_11.0.0_89a8197\components\ble\ble_advertising;.\nRF5_SDK_11.0.0_89a8197\components\softdevice\common\softdevice_handler;.\nRF5_SDK_11.0.0_89a8197\components\ble\ble_services\ble_nus;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\pstorage;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\pstorage\config;,\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\hal;.\nRF5_SDK_11.0.0_89a8197\components\libraries\fstorage\config;.\nRF5_SDK_11.0.0_89a8197\components\libraries\fstorage;.\nRF5_SDK_11.0.0_89a8197\components\libraries\experimental_section_vars;;\nRF5_SDK_11.0.0_89a8197\components\libraries\trace;.\nRF52_DFU\nRF5_SDK_11.0.0_89a8197\components\libraries\trace;.\Sources\algorithm;.\Sources\application;.\Sources\drivers;.\Sources\utils\qrcode;.\Sources\task;.\Sources\osal\inc;.\nRF5_SDK_11.0.0_89a8197\components\libraries\trace;.\Sources\gui;.\Sources\gsensor;.\Sources\utils;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\config;.\nRF5_SDK_11.0.0_89a8197\components\ble\ble_services\ble_dis;.\Sources\wechat;.\nRF5_SDK_11.0.0_89a8197\components\ble\ble_db_discovery;.\nRF5_SDK_11.0.0_89a8197\components\ble\ble_services\ble_ancs_c;.\Sources\ancc;.\nRF5_SDK_11.0.0_89a8197\external\segger_rtt;.\nRF5_SDK_11.0.0_89a8197\components\ble\ble_db_discovery;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\saadc;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\config;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\hal;.\Sources\icon;.\NRF51832_GT24L24A2Y;.\Sources\wdt
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20002080 size 0xdf80
  group Applications
    ./Sources/application/: main.c ClockTick.c UserSetting.c
  group Osal
    ./Sources/osal/src/: OSAL.c OSAL_PwrMgr.c OSAL_Task.c OSAL_Timer.c
  group Task
    ./Sources/task/: Task_Motor.c Task_GUI.c Task_Touch.c Task_Frame.c
  group nRF_Libraries
    ./NRF51832_GT24L24A2Y/: nrf52832_xxaa.lib
  group nRF_Drivers
    ./nRF5_SDK_11.0.0_89a8197/components/drivers_nrf/delay/: nrf_delay.c
  group Custom_Drivers
    ./Sources/drivers/: IRQHandler.c SPI_HW.c Button.c FPU.c LCD_ST7735.c
  group Ancs
    ./Sources/ancc/: F_Lib.c
  group GUI
    ./Sources/gui/: UI_win_main.c UI_Draw.c Window.c
  group Icon
    ./Sources/icon/: UI_main_icon.c UI_lib.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.15.0
